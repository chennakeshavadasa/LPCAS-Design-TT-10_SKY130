v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 770 -800 770 -700 {lab=#net1}
N 740 -670 770 -670 {lab=VIN_PBGR}
N 740 -830 740 -670 {lab=VIN_PBGR}
N 740 -830 770 -830 {lab=VIN_PBGR}
N 1080 -830 1110 -830 {lab=VIN_PBGR}
N 1110 -830 1110 -690 {lab=VIN_PBGR}
N 1080 -670 1110 -670 {lab=VIN_PBGR}
N 810 -670 1040 -670 {lab=vb0}
N 1110 -690 1110 -670 {lab=VIN_PBGR}
N 1080 -800 1080 -700 {lab=#net2}
N 810 -830 1040 -830 {lab=vctrl}
N 770 -920 770 -860 {lab=VIN_PBGR}
N 770 -920 1080 -920 {lab=VIN_PBGR}
N 1080 -920 1080 -860 {lab=VIN_PBGR}
N 1080 -520 1080 -440 {lab=plus}
N 1100 -290 1100 -230 {lab=GND}
N 1100 -350 1100 -290 {lab=GND}
N 1100 -410 1100 -350 {lab=GND}
N 1080 -200 1080 -130 {lab=#net3}
N 1080 -70 1080 0 {lab=GND}
N 1080 0 1100 0 {lab=GND}
N 1100 -230 1100 0 {lab=GND}
N 1080 -640 1080 -520 {lab=plus}
N 770 -640 770 -130 {lab=minus}
N 810 -100 1040 -100 {lab=GND}
N 770 0 1080 0 {lab=GND}
N 770 -70 770 0 {lab=GND}
N 930 -100 930 0 {lab=GND}
N 1080 -460 1280 -460 {lab=plus}
N 1280 -460 1280 -400 {lab=plus}
N 1280 -160 1280 -10 {lab=GND}
N 1280 -10 1280 0 {lab=GND}
N 1100 0 1280 0 {lab=GND}
N 1260 -370 1260 0 {lab=GND}
N 570 -460 770 -460 {lab=minus}
N 570 -460 570 -400 {lab=minus}
N 570 -160 570 -10 {lab=GND}
N 570 -10 570 0 {lab=GND}
N 570 0 750 0 {lab=GND}
N 590 -370 590 0 {lab=GND}
N 750 0 770 0 {lab=GND}
N 740 -920 740 -830 {lab=VIN_PBGR}
N 740 -920 770 -920 {lab=VIN_PBGR}
N 1110 -920 1110 -830 {lab=VIN_PBGR}
N 1080 -920 1110 -920 {lab=VIN_PBGR}
N 1110 -920 1170 -920 {lab=VIN_PBGR}
N 1550 -920 1550 -860 {lab=VIN_PBGR}
N 1550 -830 1580 -830 {lab=VIN_PBGR}
N 1580 -920 1580 -830 {lab=VIN_PBGR}
N 1550 -920 1580 -920 {lab=VIN_PBGR}
N 1410 -830 1510 -830 {lab=vctrl}
N 1550 -670 1580 -670 {lab=VIN_PBGR}
N 1580 -690 1580 -670 {lab=VIN_PBGR}
N 1550 -800 1550 -700 {lab=#net4}
N 1580 -830 1580 -690 {lab=VIN_PBGR}
N 1410 -670 1510 -670 {lab=vb0}
N 1500 -920 1550 -920 {lab=VIN_PBGR}
N 1550 -640 1550 -560 {lab=#net5}
N 1290 -920 1500 -920 {lab=VIN_PBGR}
N 1550 -560 1550 -340 {lab=#net5}
N 1280 0 1550 0 {lab=GND}
N 1550 -40 1550 0 {lab=GND}
N 1570 -310 1570 0 {lab=GND}
N 1550 0 1570 0 {lab=GND}
N 1550 -420 1680 -420 {lab=#net5}
N 1720 -390 1720 0 {lab=GND}
N 1570 0 1720 0 {lab=GND}
N 1720 -420 1740 -420 {lab=GND}
N 1740 -420 1740 0 {lab=GND}
N 1720 0 1740 0 {lab=GND}
N 1720 -920 1720 -790 {lab=VIN_PBGR}
N 1580 -920 1720 -920 {lab=VIN_PBGR}
N 1690 -760 1720 -760 {lab=VIN_PBGR}
N 1690 -920 1690 -760 {lab=VIN_PBGR}
N 1720 -730 1720 -450 {lab=#net6}
N 1900 -920 1900 -790 {lab=VIN_PBGR}
N 1900 -760 1930 -760 {lab=VIN_PBGR}
N 1930 -920 1930 -760 {lab=VIN_PBGR}
N 1900 -920 1930 -920 {lab=VIN_PBGR}
N 1720 -920 1900 -920 {lab=VIN_PBGR}
N 1760 -760 1860 -760 {lab=#net6}
N 1720 -680 1810 -680 {lab=#net6}
N 1810 -760 1810 -680 {lab=#net6}
N 2170 -920 2170 -860 {lab=VIN_PBGR}
N 2170 -830 2200 -830 {lab=VIN_PBGR}
N 2200 -920 2200 -830 {lab=VIN_PBGR}
N 2170 -920 2200 -920 {lab=VIN_PBGR}
N 2030 -830 2130 -830 {lab=vctrl}
N 2170 -670 2200 -670 {lab=VIN_PBGR}
N 2200 -690 2200 -670 {lab=VIN_PBGR}
N 2170 -800 2170 -700 {lab=#net7}
N 2200 -830 2200 -690 {lab=VIN_PBGR}
N 2030 -670 2130 -670 {lab=vb0}
N 2120 -920 2170 -920 {lab=VIN_PBGR}
N 2170 -640 2170 -560 {lab=VPBGR1_OUT}
N 1930 -920 2120 -920 {lab=VIN_PBGR}
N 1900 -730 1900 -560 {lab=VPBGR1_OUT}
N 1900 -560 2170 -560 {lab=VPBGR1_OUT}
N 2170 -560 2170 -500 {lab=VPBGR1_OUT}
N 1740 0 2170 0 {lab=GND}
N 2170 -20 2170 0 {lab=GND}
N 2190 -470 2190 0 {lab=GND}
N 2170 0 2190 0 {lab=GND}
N 2460 -920 2460 -860 {lab=VIN_PBGR}
N 2460 -830 2490 -830 {lab=VIN_PBGR}
N 2490 -920 2490 -830 {lab=VIN_PBGR}
N 2460 -920 2490 -920 {lab=VIN_PBGR}
N 2320 -830 2420 -830 {lab=vctrl}
N 2460 -670 2490 -670 {lab=VIN_PBGR}
N 2490 -690 2490 -670 {lab=VIN_PBGR}
N 2460 -800 2460 -700 {lab=#net8}
N 2490 -830 2490 -690 {lab=VIN_PBGR}
N 2320 -670 2420 -670 {lab=vb0}
N 2410 -920 2460 -920 {lab=VIN_PBGR}
N 2460 -640 2460 -560 {lab=#net9}
N 2460 -560 2460 -340 {lab=#net9}
N 2460 -40 2460 0 {lab=GND}
N 2480 -310 2480 0 {lab=GND}
N 2460 0 2480 0 {lab=GND}
N 2460 -420 2590 -420 {lab=#net9}
N 2630 -390 2630 0 {lab=GND}
N 2480 0 2630 0 {lab=GND}
N 2630 -420 2650 -420 {lab=GND}
N 2650 -420 2650 0 {lab=GND}
N 2630 0 2650 0 {lab=GND}
N 2630 -920 2630 -790 {lab=VIN_PBGR}
N 2490 -920 2630 -920 {lab=VIN_PBGR}
N 2600 -760 2630 -760 {lab=VIN_PBGR}
N 2600 -920 2600 -760 {lab=VIN_PBGR}
N 2630 -730 2630 -450 {lab=#net10}
N 2810 -920 2810 -790 {lab=VIN_PBGR}
N 2810 -760 2840 -760 {lab=VIN_PBGR}
N 2840 -920 2840 -760 {lab=VIN_PBGR}
N 2810 -920 2840 -920 {lab=VIN_PBGR}
N 2630 -920 2810 -920 {lab=VIN_PBGR}
N 2670 -760 2770 -760 {lab=#net10}
N 2630 -680 2720 -680 {lab=#net10}
N 2720 -760 2720 -680 {lab=#net10}
N 3080 -920 3080 -860 {lab=VIN_PBGR}
N 3080 -830 3110 -830 {lab=VIN_PBGR}
N 3110 -920 3110 -830 {lab=VIN_PBGR}
N 3080 -920 3110 -920 {lab=VIN_PBGR}
N 2940 -830 3040 -830 {lab=vctrl}
N 3080 -670 3110 -670 {lab=VIN_PBGR}
N 3110 -690 3110 -670 {lab=VIN_PBGR}
N 3080 -800 3080 -700 {lab=#net11}
N 3110 -830 3110 -690 {lab=VIN_PBGR}
N 2940 -670 3040 -670 {lab=vb0}
N 3030 -920 3080 -920 {lab=VIN_PBGR}
N 3080 -640 3080 -560 {lab=VPBGR2_OUT}
N 2840 -920 3030 -920 {lab=VIN_PBGR}
N 2810 -730 2810 -560 {lab=VPBGR2_OUT}
N 2810 -560 3080 -560 {lab=VPBGR2_OUT}
N 3080 -560 3080 -500 {lab=VPBGR2_OUT}
N 2650 0 3080 0 {lab=GND}
N 3080 -20 3080 0 {lab=GND}
N 3100 -470 3100 0 {lab=GND}
N 3080 0 3100 0 {lab=GND}
N 2200 -920 2410 -920 {lab=VIN_PBGR}
N 2190 0 2460 0 {lab=GND}
N 2460 -100 2460 -40 {lab=GND}
N 1550 -100 1550 -40 {lab=GND}
N 950 -460 1080 -460 {lab=plus}
N 770 -460 910 -460 {lab=minus}
N -770 -790 -770 -760 {lab=VIN_PBGR}
N -770 -730 -770 -680 {lab=vb0}
N -770 -680 -680 -680 {lab=vb0}
N -680 -760 -680 -680 {lab=vb0}
N -730 -760 -680 -760 {lab=vb0}
N -770 -920 -770 -790 {lab=VIN_PBGR}
N -770 -90 -770 0 {lab=GND}
N -770 -680 -770 -570 {lab=vb0}
N -790 -540 -790 0 {lab=GND}
N -790 0 -770 0 {lab=GND}
N 310 -0 570 -0 {lab=GND}
N 310 -920 740 -920 {lab=VIN_PBGR}
N 1220 -920 1290 -920 {lab=VIN_PBGR}
N 1210 -920 1220 -920 {lab=VIN_PBGR}
N 1170 -920 1210 -920 {lab=VIN_PBGR}
N -30 -610 -30 -570 {lab=#net12}
N -30 -570 190 -570 {lab=#net12}
N 190 -610 190 -570 {lab=#net12}
N -30 -640 190 -640 {lab=GND}
N 80 -570 80 -510 {lab=#net12}
N 100 -640 100 -480 {lab=GND}
N 80 -480 100 -480 {lab=GND}
N 100 -480 100 -420 {lab=GND}
N 80 -420 100 -420 {lab=GND}
N 80 -450 80 -420 {lab=GND}
N -30 -800 -30 -670 {lab=#net13}
N -30 -860 -30 -830 {lab=VIN_PBGR}
N 190 -860 190 -830 {lab=VIN_PBGR}
N 190 -800 190 -670 {lab=#net14}
N 10 -830 150 -830 {lab=#net13}
N -30 -920 -30 -860 {lab=VIN_PBGR}
N -30 -920 190 -920 {lab=VIN_PBGR}
N 190 -920 190 -860 {lab=VIN_PBGR}
N -30 -780 30 -780 {lab=#net13}
N 30 -830 30 -780 {lab=#net13}
N -280 -480 40 -480 {lab=#net15}
N -320 -420 80 -420 {lab=GND}
N -320 -450 -320 -420 {lab=GND}
N -320 -480 -320 -450 {lab=GND}
N -320 -540 -320 -510 {lab=#net15}
N -320 -530 -250 -530 {lab=#net15}
N -250 -530 -250 -480 {lab=#net15}
N -340 -810 -340 -570 {lab=GND}
N -340 -570 -340 -420 {lab=GND}
N -340 -420 -320 -420 {lab=GND}
N -360 -840 -320 -840 {lab=#net16}
N -510 -920 -510 -900 {lab=VIN_PBGR}
N -510 -920 -30 -920 {lab=VIN_PBGR}
N -510 -540 -360 -540 {lab=#net17}
N -490 -870 -490 -570 {lab=GND}
N -490 -690 -340 -690 {lab=GND}
N -760 -920 -510 -920 {lab=VIN_PBGR}
N -770 -920 -760 -920 {lab=VIN_PBGR}
N 230 -640 300 -640 {lab=plus}
N -140 -640 -70 -640 {lab=minus}
N 190 -920 310 -920 {lab=VIN_PBGR}
N 460 -450 460 -420 {lab=GND}
N 100 -420 460 -420 {lab=GND}
N 40 -480 40 -470 {lab=#net15}
N 40 -470 180 -470 {lab=#net15}
N 180 -480 180 -470 {lab=#net15}
N 180 -480 420 -480 {lab=#net15}
N 460 -480 460 -450 {lab=GND}
N 260 -820 420 -820 {lab=#net14}
N 260 -820 260 -740 {lab=#net14}
N 190 -740 260 -740 {lab=#net14}
N 460 -790 460 -510 {lab=vctrl}
N 460 -920 460 -850 {lab=VIN_PBGR}
N 460 -850 460 -820 {lab=VIN_PBGR}
N 390 -720 390 -420 {lab=GND}
N 340 -740 360 -740 {lab=#net18}
N 260 -740 280 -740 {lab=#net14}
N 420 -740 460 -740 {lab=vctrl}
N 460 -640 600 -640 {lab=vctrl}
N 960 -500 960 -460 {lab=plus}
N 900 -500 900 -460 {lab=minus}
N 3350 -920 3350 -860 {lab=VIN_PBGR}
N 3350 -830 3380 -830 {lab=VIN_PBGR}
N 3380 -920 3380 -830 {lab=VIN_PBGR}
N 3350 -920 3380 -920 {lab=VIN_PBGR}
N 3210 -830 3310 -830 {lab=vctrl}
N 3350 -670 3380 -670 {lab=VIN_PBGR}
N 3380 -690 3380 -670 {lab=VIN_PBGR}
N 3350 -800 3350 -700 {lab=#net19}
N 3380 -830 3380 -690 {lab=VIN_PBGR}
N 3210 -670 3310 -670 {lab=vb0}
N 3300 -920 3350 -920 {lab=VIN_PBGR}
N 3350 -640 3350 -560 {lab=#net20}
N 3350 -560 3350 -340 {lab=#net20}
N 3350 -40 3350 0 {lab=GND}
N 3370 -310 3370 0 {lab=GND}
N 3350 0 3370 0 {lab=GND}
N 3350 -100 3350 -40 {lab=GND}
N 3110 -920 3300 -920 {lab=VIN_PBGR}
N 3100 0 3350 0 {lab=GND}
N 3520 -390 3520 0 {lab=GND}
N 3520 -420 3540 -420 {lab=GND}
N 3540 -420 3540 0 {lab=GND}
N 3520 0 3540 0 {lab=GND}
N 3520 -920 3520 -790 {lab=VIN_PBGR}
N 3490 -760 3520 -760 {lab=VIN_PBGR}
N 3490 -920 3490 -760 {lab=VIN_PBGR}
N 3520 -730 3520 -450 {lab=#net21}
N 3740 -920 3740 -790 {lab=VIN_PBGR}
N 3740 -760 3770 -760 {lab=VIN_PBGR}
N 3770 -920 3770 -760 {lab=VIN_PBGR}
N 3740 -920 3770 -920 {lab=VIN_PBGR}
N 3520 -920 3700 -920 {lab=VIN_PBGR}
N 3560 -760 3660 -760 {lab=#net21}
N 3380 -920 3520 -920 {lab=VIN_PBGR}
N 3350 -420 3480 -420 {lab=#net20}
N 3370 0 3520 0 {lab=GND}
N 3990 -20 3990 0 {lab=GND}
N 4010 -470 4010 0 {lab=GND}
N 3700 -920 3740 -920 {lab=VIN_PBGR}
N 3660 -760 3700 -760 {lab=#net21}
N 3540 -0 3740 0 {lab=GND}
N 3990 -920 3990 -860 {lab=VIN_PBGR}
N 3990 -830 4020 -830 {lab=VIN_PBGR}
N 4020 -920 4020 -830 {lab=VIN_PBGR}
N 3990 -920 4020 -920 {lab=VIN_PBGR}
N 3850 -830 3950 -830 {lab=vctrl}
N 3990 -670 4020 -670 {lab=VIN_PBGR}
N 4020 -690 4020 -670 {lab=VIN_PBGR}
N 3990 -800 3990 -700 {lab=#net22}
N 4020 -830 4020 -690 {lab=VIN_PBGR}
N 3850 -670 3950 -670 {lab=vb0}
N 3940 -920 3990 -920 {lab=VIN_PBGR}
N 3990 -640 3990 -560 {lab=VPBGR3_OUT}
N 3990 -560 3990 -500 {lab=VPBGR3_OUT}
N 3990 -0 4010 0 {lab=GND}
N 3740 0 3990 -0 {lab=GND}
N 3770 -920 3940 -920 {lab=VIN_PBGR}
N 3740 -730 3740 -580 {lab=VPBGR3_OUT}
N 3740 -580 3990 -580 {lab=VPBGR3_OUT}
N 3630 -760 3630 -660 {lab=#net21}
N 3520 -660 3630 -660 {lab=#net21}
N 3990 -500 4150 -500 {lab=VPBGR3_OUT}
N 3990 -440 4150 -440 {lab=#net23}
N 4010 -470 4150 -470 {lab=GND}
N 4190 -470 4260 -470 {lab=#net24}
N 3990 -380 4150 -380 {lab=#net25}
N 4010 -410 4150 -410 {lab=GND}
N 4190 -410 4260 -410 {lab=#net26}
N 3990 -320 4150 -320 {lab=#net27}
N 4010 -350 4150 -350 {lab=GND}
N 4190 -350 4260 -350 {lab=#net28}
N 3990 -260 4150 -260 {lab=#net29}
N 4010 -290 4150 -290 {lab=GND}
N 4190 -290 4260 -290 {lab=#net30}
N 3990 -200 4150 -200 {lab=#net31}
N 4010 -230 4150 -230 {lab=GND}
N 4190 -230 4260 -230 {lab=#net32}
N 3990 -140 4150 -140 {lab=#net33}
N 4010 -170 4150 -170 {lab=GND}
N 4190 -170 4260 -170 {lab=#net34}
N 3990 -80 4150 -80 {lab=#net35}
N 4010 -110 4150 -110 {lab=GND}
N 4190 -110 4260 -110 {lab=#net36}
N 3990 -20 4150 -20 {lab=GND}
N 4010 -50 4150 -50 {lab=GND}
N 4190 -50 4260 -50 {lab=#net37}
N 3990 -580 4200 -580 {lab=VPBGR3_OUT}
N 3080 -560 3160 -560 {lab=VPBGR2_OUT}
N 2170 -560 2250 -560 {lab=VPBGR1_OUT}
N -950 -920 -770 -920 {lab=VIN_PBGR}
N -970 0 -790 0 {lab=GND}
N -180 -920 -180 -860 {lab=VIN_PBGR}
N -180 -860 -140 -860 {lab=VIN_PBGR}
N -140 -920 -140 -860 {lab=VIN_PBGR}
N 370 -30 370 -0 {lab=GND}
N 370 -90 370 -30 {lab=GND}
N 370 -120 370 -90 {lab=GND}
N 350 -120 370 -120 {lab=GND}
N 370 -120 390 -120 {lab=GND}
N 370 -60 390 -60 {lab=GND}
N 350 -60 370 -60 {lab=GND}
N 80 -0 120 -0 {lab=GND}
N 100 -30 100 -0 {lab=GND}
N 100 -60 100 -30 {lab=GND}
N 80 -60 100 -60 {lab=GND}
N 100 -60 120 -60 {lab=GND}
N 100 -90 100 -60 {lab=GND}
N 100 -120 100 -90 {lab=GND}
N 80 -120 100 -120 {lab=GND}
N 100 -120 120 -120 {lab=GND}
N 120 0 310 0 {lab=GND}
N -100 -60 -100 -0 {lab=GND}
N -140 -60 -100 -60 {lab=GND}
N -140 -60 -140 -0 {lab=GND}
N -140 -0 -100 0 {lab=GND}
N -100 0 80 0 {lab=GND}
N -300 0 -140 0 {lab=GND}
N -280 -90 -280 -0 {lab=GND}
N -280 -120 -280 -100 {lab=#net38}
N -300 -120 -280 -120 {lab=#net38}
N -280 -120 -260 -120 {lab=#net38}
N -280 -60 -260 -60 {lab=GND}
N -300 -60 -280 -60 {lab=GND}
N -560 -120 -560 -0 {lab=GND}
N -580 -120 -560 -120 {lab=GND}
N -560 -120 -540 -120 {lab=GND}
N -560 -60 -540 -60 {lab=GND}
N -580 -60 -560 -60 {lab=GND}
N -580 0 -540 0 {lab=GND}
N -540 0 -300 0 {lab=GND}
N -40 -420 -40 0 {lab=GND}
N -770 -0 -580 -0 {lab=GND}
N -880 -600 -880 0 {lab=GND}
N -880 -630 -880 -600 {lab=GND}
N -950 -630 -920 -630 {lab=#net39}
N -880 -700 -880 -660 {lab=#net40}
C {sky130_fd_pr/pfet_01v8.sym} 790 -830 0 1 {name=M1
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 790 -670 0 1 {name=M2
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1060 -830 0 0 {name=M3
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1060 -670 0 0 {name=M4
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1080 -410 0 1 {name=R1
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1080 -350 0 1 {name=R2
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1080 -290 0 1 {name=R3
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1080 -230 0 1 {name=R4
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/pnp_05v5.sym} 1060 -100 0 0 {name=Q1
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 790 -100 0 1 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1280 -370 0 0 {name=R5
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1280 -310 0 0 {name=R6
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1280 -250 0 0 {name=R7
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1280 -190 0 0 {name=R8
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 570 -370 0 1 {name=R9
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 570 -310 0 1 {name=R10
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 570 -250 0 1 {name=R11
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 570 -190 0 1 {name=R12
L=21.11
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {lab_pin.sym} 930 -830 1 0 {name=p1 sig_type=std_logic lab=vctrl}
C {lab_pin.sym} 830 -670 1 0 {name=p2 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/pfet_01v8.sym} 1530 -830 0 0 {name=M7
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1410 -830 1 0 {name=p5 sig_type=std_logic lab=vctrl}
C {sky130_fd_pr/pfet_01v8.sym} 1530 -670 0 0 {name=M8
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 1410 -670 1 0 {name=p6 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1550 -310 0 1 {name=R21
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1700 -420 0 0 {name=M9
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1740 -760 0 1 {name=M10
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1880 -760 0 0 {name=M11
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2150 -830 0 0 {name=M12
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2030 -830 1 0 {name=p7 sig_type=std_logic lab=vctrl}
C {sky130_fd_pr/pfet_01v8.sym} 2150 -670 0 0 {name=M13
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2030 -670 1 0 {name=p8 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -470 0 1 {name=R27
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -410 0 1 {name=R28
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -350 0 1 {name=R29
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -290 0 1 {name=R30
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -230 0 1 {name=R31
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -170 0 1 {name=R32
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -110 0 1 {name=R33
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2170 -50 0 1 {name=R34
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 2440 -830 0 0 {name=M14
W=5.4
L=3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2320 -830 1 0 {name=p12 sig_type=std_logic lab=vctrl}
C {lab_pin.sym} 2320 -670 1 0 {name=p13 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2460 -310 0 1 {name=R36
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2610 -420 0 0 {name=M16
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2650 -760 0 1 {name=M17
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2790 -760 0 0 {name=M18
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3060 -830 0 0 {name=M19
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2940 -830 1 0 {name=p14 sig_type=std_logic lab=vctrl}
C {sky130_fd_pr/pfet_01v8.sym} 3060 -670 0 0 {name=M20
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 2940 -670 1 0 {name=p15 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -470 0 1 {name=R41
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -410 0 1 {name=R42
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -350 0 1 {name=R43
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -290 0 1 {name=R44
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -230 0 1 {name=R45
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -170 0 1 {name=R46
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -110 0 1 {name=R47
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3080 -50 0 1 {name=R48
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2460 -250 0 1 {name=R35
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2460 -130 0 1 {name=R37
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 2460 -190 0 1 {name=R38
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/pfet_01v8.sym} 2440 -670 0 0 {name=M15
W=5.4
L=3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {spice_probe_vdiff.sym} 930 -460 1 0 {name=p17}
C {sky130_fd_pr/pfet_01v8.sym} -750 -760 0 1 {name=M21
W=6.75
L=3
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -540 0 0 {name=R26
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -480 0 0 {name=R39
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -420 0 0 {name=R40
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -360 0 0 {name=R49
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -300 0 0 {name=R50
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -240 0 0 {name=R51
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -180 0 0 {name=R52
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -770 -120 0 0 {name=R53
L=2.9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {lab_pin.sym} -680 -720 2 0 {name=p18 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1550 -250 0 1 {name=R22
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1550 -130 0 1 {name=R23
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 1550 -190 0 1 {name=R24
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {ngspice_probe.sym} 1080 -460 0 0 {name=r25}
C {ngspice_probe.sym} 770 -460 0 1 {name=r54}
C {ngspice_probe.sym} 1550 -420 0 1 {name=r55}
C {ngspice_probe.sym} 2460 -420 0 1 {name=r56}
C {ngspice_probe.sym} 2630 -560 0 1 {name=r57}
C {ngspice_probe.sym} 1720 -580 0 1 {name=r58}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -50 -640 0 0 {name=M5
W=2.25
L=1.5
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 210 -640 0 1 {name=M6
W=2.25
L=1.5
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 60 -480 0 0 {name=M22
W=2
L=2.5
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -10 -830 0 1 {name=M23
W=3
L=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 170 -830 0 0 {name=M24
W=3
L=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -300 -480 0 1 {name=M25
W=2
L=2.5
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -320 -570 0 0 {name=R13
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -320 -630 0 0 {name=R14
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -320 -690 0 0 {name=R15
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -320 -750 0 0 {name=R16
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -320 -810 0 0 {name=R17
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -360 -570 0 1 {name=R18
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -360 -630 0 1 {name=R19
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -360 -690 0 1 {name=R20
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -360 -750 0 1 {name=R59
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -360 -810 0 1 {name=R60
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -510 -570 0 1 {name=R61
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -510 -630 0 1 {name=R62
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -510 -690 0 1 {name=R63
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -510 -750 0 1 {name=R64
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -510 -810 0 1 {name=R65
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -510 -870 0 1 {name=R66
L=9
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {lab_pin.sym} 300 -640 0 1 {name=p3 sig_type=std_logic lab=plus}
C {lab_pin.sym} -140 -640 0 0 {name=p4 sig_type=std_logic lab=minus}
C {sky130_fd_pr/nfet_01v8.sym} 440 -480 0 0 {name=M26
W=8
L=2.5
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 440 -820 0 0 {name=M27
W=4.25
L=1
nf=1
mult=8
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 390 -740 1 1 {name=R67
L=3.5
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 310 -740 3 0 {name=C1 model=cap_mim_m3_1 W=9.75 L=9.75 MF=8 spiceprefix=X}
C {lab_pin.sym} 600 -640 2 0 {name=p10 sig_type=std_logic lab=vctrl}
C {lab_pin.sym} 900 -500 3 1 {name=p11 sig_type=std_logic lab=minus}
C {lab_pin.sym} 960 -500 3 1 {name=p19 sig_type=std_logic lab=plus}
C {sky130_fd_pr/pfet_01v8.sym} 3330 -830 0 0 {name=M28
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3210 -830 1 0 {name=p20 sig_type=std_logic lab=vctrl}
C {sky130_fd_pr/pfet_01v8.sym} 3330 -670 0 0 {name=M29
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3210 -670 1 0 {name=p21 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3350 -310 0 1 {name=R68
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {ngspice_probe.sym} 3350 -420 0 1 {name=r72}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3350 -250 0 1 {name=R69
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3350 -190 0 1 {name=R70
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3350 -130 0 1 {name=R71
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 3500 -420 0 0 {name=M30
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3540 -760 0 1 {name=M31
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3720 -760 0 0 {name=M32
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {ngspice_probe.sym} 3520 -580 0 1 {name=r73}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -470 0 1 {name=R74
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -410 0 1 {name=R75
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -350 0 1 {name=R76
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -290 0 1 {name=R77
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -230 0 1 {name=R78
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -170 0 1 {name=R79
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -110 0 1 {name=R80
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 3990 -50 0 1 {name=R81
L=5.61
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -470 0 1 {name=M33
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 3970 -830 0 0 {name=M34
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3850 -830 0 0 {name=p22 sig_type=std_logic lab=vctrl}
C {sky130_fd_pr/pfet_01v8.sym} 3970 -670 0 0 {name=M35
W=6.75
L=3
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {lab_pin.sym} 3850 -670 0 0 {name=p23 sig_type=std_logic lab=vb0}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -410 0 1 {name=M36
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -350 0 1 {name=M37
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -290 0 1 {name=M38
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -230 0 1 {name=M39
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -170 0 1 {name=M40
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -110 0 1 {name=M41
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 4170 -50 0 1 {name=M42
W=10
L=0.15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {opin.sym} 4200 -580 0 0 {name=p24 lab=VPBGR3_OUT}
C {opin.sym} 3160 -560 0 0 {name=p16 lab=VPBGR2_OUT}
C {opin.sym} 2250 -560 0 0 {name=p9 lab=VPBGR1_OUT}
C {ipin.sym} -950 -920 0 0 {name=p25 lab=VIN_PBGR}
C {ipin.sym} -970 0 0 0 {name=p26 lab=GND}
C {sky130_fd_pr/pfet_01v8.sym} -160 -890 0 1 {name=M43
W=3
L=1
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 390 -30 0 0 {name=R82
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 350 -30 0 1 {name=R83
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 390 -90 0 0 {name=R84
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 350 -90 0 1 {name=R85
L=2.262
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 120 -30 0 0 {name=R86
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 80 -30 0 1 {name=R87
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 80 -90 0 1 {name=R88
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} 120 -90 0 0 {name=R89
L=3.7
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8.sym} -120 -30 0 0 {name=M44
W=8
L=2.5
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -260 -30 0 0 {name=R90
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -300 -30 0 1 {name=R91
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -260 -90 0 0 {name=R92
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -300 -90 0 1 {name=R93
L=18
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -540 -30 0 0 {name=R94
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -580 -30 0 1 {name=R95
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -540 -90 0 0 {name=R96
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -580 -90 0 1 {name=R97
L=4.15
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -900 -630 0 0 {name=M45
W=1
L=0.15
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_pin.sym} -880 -700 1 0 {name=p27 sig_type=std_logic lab=vctrl}
C {ipin.sym} -950 -630 0 0 {name=p28 lab=Startup_PBGR}
C {ipin.sym} 4260 -470 0 1 {name=p29 lab=SW1_PBGR}
C {ipin.sym} 4260 -410 0 1 {name=p30 lab=SW2_PBGR}
C {ipin.sym} 4260 -350 0 1 {name=p31 lab=SW3_PBGR}
C {ipin.sym} 4260 -290 0 1 {name=p32 lab=SW4_PBGR}
C {ipin.sym} 4260 -230 0 1 {name=p33 lab=SW5_PBGR}
C {ipin.sym} 4260 -170 0 1 {name=p34 lab=SW6_PBGR}
C {ipin.sym} 4260 -110 0 1 {name=p35 lab=SW7_PBGR}
C {ipin.sym} 4260 -50 0 1 {name=p36 lab=SW8_PBGR}
